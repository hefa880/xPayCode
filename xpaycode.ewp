# IAR project xpaycode.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: DEV\STM32F10x_StdPeriph_Driver\inc; DEV\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; DEV\CMSIS\CM3\CoreSupport; BSP\in\flash; BSP\in\g510; BSP\in\io; BSP\in\oled; BSP\in\rtc; BSP\in\wifi; BSP\in; APP\in\aes; APP\in\key; APP\in\pay; APP\in\protocol; APP\in\record; APP\in\time; APP\in\ui; APP\in; DEV\CMSIS\CM3\DeviceSupport\ST\STM32F10x; DEV\STM32F10x_StdPeriph_Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: xpaycode.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    APP/src/: main.c
  group dev
    DEV/STM32F10x_StdPeriph_Driver/: stm32f10x_it.c
  group dev/CMSIS
    DEV/CMSIS/CM3/CoreSupport/: core_cm3.c
    DEV/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    DEV/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group dev/STM32F10x_StdPeriph_Driver
    DEV/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
